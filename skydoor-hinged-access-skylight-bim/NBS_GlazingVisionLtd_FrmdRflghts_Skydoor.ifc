Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T15:58:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 15:58:28 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{376AD5A4-3DD2-4F90-89D9-8D04BA6A7238}\ifc* Database version: 5507* Database creation date: Wed Jan 25 15:58:26 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 15:58:27 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 15:58:27 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_Skydoor.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcWindow: DoubleGlazed-2400x1200mm_6-20-6mm, NBS_GlazingVisionLtd_FrmdRflghts_Skydoor:DoubleGlazed-2400x1200mm_6-20-6mm:187599
In: Level 1
Type - ConstructionType: OTHER_CONSTRUCTION; OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_72_31 (Uniclass2015); Material: NBS_Concept, NBS_Glass_Double
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_Skydoor_DoubleGlazed; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/fha0aiyi; NBSDescription: Framed rooflights; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-99/410; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/rooflights/hinged-rooflights/skydoor-hinged-access-rooflight/; Revision: n/a; Uniclass2015Code: Pr_30_59_72_31; Uniclass2015Title: Framed rooflights; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: Remote control, rain sensor, thermostat, BMS integration, RITEC coating, Security system integration, External mounted key switch; CavityType: 20 mm black silicone sealed warm edge argon filled; Certification: n/a; Configuration: n/a; DriveMechanism: Pair of Simon RWA folding arm actuators; Form: Flat rectangular; FrameFinishCoating: Qualicoat approved polyester powder coating; FrameFinishColour: RAL 7015 Grey (Outer), RAL 9010 White (Inner); FrameFinishTexture: n/a; FrameMaterial: Aluminium; GlazingOptions: Double, triple; GlazingOrInfillCoating: Low-e coating; GlazingOrInfillConstruction: Double glazed; GlazingOrInfillType: Insulating glass unit; InnerPaneType: 6 mm heat soak tested soft low e toughened; IntermediatePaneType: n/a; MaximumArea: 4.5 m²; MaximumSize: 3800 mm width (hinge) 2100 mm span; MinimumSize: 1300 mm width (hinge) 1000 mm span; OpeningAngle: 87°; OpeningType: Hinged for access; OperationControl: On board control PCB; OperationType: Internal 24 V, 14.6 A, 300 W switch mode power supply; OuterPaneType: 6 mm heat soak tested toughened; PitchAngleRange: 3-10°; RooflightWeight: 250 kg (2400 x 1000 mm); Seals: Combination of three silicone bubble seals; Security: Mechanism cannot be disconnected from lid whilst closed, mechanisms cannot be back driven; StructuralKerb: To builders kerb (others) min 200 mm wide, 150 mm high, 3° pitch; ThermalBreak: yes; WholeWindowUValue: 2.2 W/m²K Uw
Type - Pset_WindowCommon - AcousticRating: 31 db; FireRating: n/a; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: yes; Reference: n/a; SecurityRating: n/a; SmokeStop: no; ThermalTransmittance: 0
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: Argon; GlassColor: Clear; GlassLayers: 2; GlassThickness1: 6 mm; GlassThickness2: 6 mm; GlassThickness3: 0 mm; IsCoated: yes; IsLaminated: no; IsTempered: yes; IsWired: no; Reflectivity: 0; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 300; HasProtectiveEarth: no; InsulationStandardClass: n/a; IP_Code: n/a; NominalCurrent: 14.6; NominalFrequencyRange: n/a; NominalVoltage: 24 V; NumberOfPoles: 0; PhaseAngle: 0; PhaseReference: n/a; UsageCurrent: 14.6
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_72_31: Framed rooflights; CodePerformance: n/a; Color: Grey/white frame, clear glass; Constituents: Aluminium frame, double IGU; Description: Double glazed 90° access and ventilation rooflight for flat roof applications; DurationUnit: year; ExpectedLife: n/a; Features: Hinged access rooflight, opens to 87 degrees, suitable for regular acccess, integrated proximity detectors; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 406; ModelReference: GV Skydoor Double Glazed; Name: FramedRooflights_Skydoor_DoubleGlazed_GlazingVisionLtd; NominalHeight: 0 mm; NominalLength: 1198.6 mm; NominalWidth: 2398.6 mm; ReplacementCost: n/a; Shape: Rectangular; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2 (installed by others) or 10 years (installed by Glazing Vision); WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 344.1 mm; OverallWidth: 2399.58 mm
NBS_Data - ComponentNumber: n/a; WindowNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
