Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2017-01-25T15:44:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 15.7.0.0 - Alternate UI 15.7.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Jan 25 15:44:59 2017* Host: NCL-PI08* Database: C:\Users\KovacsG\AppData\Local\Temp\{AAD5AF92-4B16-41DC-8D80-3E34D0F12A26}\ifc* Database version: 5507* Database creation date: Wed Jan 25 15:44:59 2017* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Jan 25 15:44:59 2017* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Jan 25 15:44:59 2017* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: X:\NBL\Manufacturer\G\Glazing Vision_12688\NBLA0680\Authoring\IFC\NBS_GlazingVisionLtd_FrmdRflghts_FlushglazeEaves.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcWindow: DoubleGlazed-1200x1200x1200mm_6-16-6mm, NBS_GlazingVisionLtd_FrmdRflghts_FlushglazeEaves:DoubleGlazed-1200x1200x1200mm_6-16-6mm:186202
In: Level 1
Type - ConstructionType: OTHER_CONSTRUCTION; OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no; Classification: Pr_30_59_72_31 (Uniclass2015); Material: NBS_Concept, NBS_Glass_Double
Type - NBS_General - Author: NBS; BIMObjectName: NBS_GlazingVisionLtd_FramedRooflights_FlushglazeEaves_DoubleGlazed; ManufacturerName: Glazing Vision Ltd; ManufacturerURL: www.glazingvision.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/cebulnyb; NBSDescription: Framed rooflights; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-99/410; NBSTypeID: n/a; ProductInformation: www.glazingvision.co.uk/rooflights/fixed-rooflights/flushglaze-eaves-rooflight/; Revision: n/a; Uniclass2015Code: Pr_30_59_72_31; Uniclass2015Title: Framed rooflights; Uniclass2015Version: Products v1.3; Version: 1
Type - NBS_Data - Accessories: n/a; CavityType: 16 mm black silicone sealed warm edge argon filled; Certification: BBA Certificate; DesignLoads: n/a; Form: Eave; FrameFinishCoating: Qualicoat approved polyester powder coating; FrameFinishColour: RAL7015 Grey; FrameFinishTexture: n/a; FrameMaterial: Aluminium; GlazingOptions: Double, triple; GlazingOrInfillCoating: Low-e coating; GlazingOrInfillConstruction: Double glazed; GlazingOrInfillType: Insulating glass units; InnerPaneType: 6 mm heat soak tested soft low e toughened; IntermediatePaneType: n/a; LightTransmission: 0.77; MaximumArea: 5.2 m² per section based on standard 6/16/6 glass spec; MaximumSize: 1600 mm width x 4000 mm span x 4000 mm height; MinimumSize: 400 mm; OperationControl: n/a; OperationType: Fixed; OuterPaneType: 6 mm heat soak tested toughened; PitchAngleRange: 3-50°; RooflightWeight: 97 kg; Seals: Silicone, polybutyl and rubber seals; ShadingCoefficient: 0.71; StructuralKerb: n/a; ThermalBreak: no; WholeWindowUValue: 3.2 W/m²K Uw
Type - Pset_WindowCommon - AcousticRating: 31 dB; FireRating: n/a; GlazingAreaFraction: 0; Infiltration: 0; IsExternal: yes; Reference: n/a; SecurityRating: n/a; SmokeStop: no; ThermalTransmittance: 0
Type - Pset_DoorWindowGlazingType - BeamRadiationTransmittance: 0; FillGas: Argon; GlassColor: Clear; GlassLayers: 2; GlassThickness1: 6 mm; GlassThickness2: 6 mm; GlassThickness3: 0 mm; IsCoated: yes; IsLaminated: no; IsTempered: yes; IsWired: no; Reflectivity: 0.11; SolarHeatGainTransmittance: 0; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0; Translucency: 0
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_30_59_72_31: Framed rooflights; CodePerformance: n/a; Color: Grey frame, clear glass; Constituents: Aluminium frame, glass pane; Description: Double glazed fixed rooflight with vertical and horizontal sections, no visible internal framework; DurationUnit: year; ExpectedLife: n/a; Features: Dual aspect design, no visible fixings, no external capping, heat soak tested low-e safety glass as standard; Finish: n/a; Grade: n/a; Manufacturer: sales@glazingvision.co.uk; Material: Aluminium, glass; ModelNumber: 402; ModelReference: GV Flushglaze Double Glazed Eaves Rooflight; Name: FramedRooflights_FlushglazeEaves_DoubleGlazed_GlazingVisionLtd; NominalHeight: 1200 mm; NominalLength: 1200 mm; NominalWidth: 1200 mm; ReplacementCost: n/a; Shape: Angled; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: Manufacturer's warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2 (installed by others) or 10 years (installed by Glazing Vision); WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: customerservices@glazingvision.co.uk
OverallHeight: 1221.3 mm; OverallWidth: 1220 mm
NBS_Data - ComponentNumber: n/a; WindowNumber: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
